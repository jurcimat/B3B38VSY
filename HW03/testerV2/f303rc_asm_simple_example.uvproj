# Keil uVision project f303rc_asm_simple_example.uvproj, settings and files
target tester_v2 (ARM-ADS)
  device: STM32F303RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: tester_v2 +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group simple_example
    ./: startup_stm32f30x.s stm32f303xe.s tester_v2.s
